options:
  parameters:
    author: pi
    generate_options: no_gui
    id: RF_Logging
    output_language: python
    title: reciverfilesink2.3
  states: {}

blocks:
- name: bpak
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pi/datafile-1.dat
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/pi/datafile-11.dat
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '1024'
    vlen_out: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpak
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    use_snr: 'True'
    w: '12000'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: fcdproplus_fcdproplus_0
  id: fcdproplus_fcdproplus
  parameters:
    devicename: ''
    freq: '426000000'
    if_gain: '1'
    lnaswitch: '1'
    mixergainswitch: '1'
    ppm: '0'
    unit: '1'
  states: {}
- name: import_0
  id: import
  parameters: {}
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_max_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_file_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_uchar_to_float_0, '0']
- [fcdproplus_fcdproplus_0, '0', digital_costas_loop_cc_0, '0']
- [fcdproplus_fcdproplus_0, '0', logpwrfft_x_0, '0']
- [logpwrfft_x_0, '0', blocks_max_xx_0, '0']

metadata:
  file_format: 1
